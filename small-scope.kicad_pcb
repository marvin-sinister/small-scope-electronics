# Repository marvin-sinister/small-scope-electronics

File README.md:

# small-scope-electronics
Schematics for [small-scope](https://github.com/marvin-sinister/small-scope) arduino oscilloscope

This is a kicad project containing schematics and PCB for [small-scope](https://github.com/marvin-sinister/small-scope) arduino shield.

The shield has not yet been tested, so treat with care. The PCB is single sided so should be reasonably simple to make.

Some of the features:
 * 1, 5, 10, 20 attenuation
 * digital or analog trigger threshold
 * optional external Vref
 * AC/DC choice
 * some safety™
 * power supply choice

*some safety™* being the resistor/zenner circuit at OP amp to µc, which should help keep the ATmega safe within reason.

*power supply choice* means that the OP amp can be powered with either 5V from USB or whatever you connect to Vin (so up to 12V, 9V recommended).

The reason for this is the fact that the LM324N will output voltages in ~0.6-3.8V range on 5V supply. The 9V should have plenty of room to reach the 5V. It would be ideal to have some negative voltage and OP amp which can be biased to increase the range to 0-5V, but that would complicate the whole thing beyond the idea of being simple.

## KiCad design small-scope.kicad_pcb

Parts:
C1, C11: 10u
C2: 1u
C3, C4: 1n
C5: 16p
C6: 10p
C7: 130p
C8, C9: 270p
C10: 10u/35V
D1, D2: 5.1V
D3, D4: LED
JP1: VDD SRC
JP2: DC BIAS
JP3: THR SRC
JP4: ATT SEL
JP5: AC/DC
P1: BNC
P2: AREF
R1, R9, R10, R16: 220
R2, R3, R4, R5, R6, R7, R17, R18, R19: 10k
R8: 1k8
R11: 50
R12: 800k
R13: 100k
R14, R15: 50k
RV1, RV2: 10k
SHIELD1: ARDUINO_SHIELD
SW1: STAT DIS
U1: LM324N

Connections:
/2.5V: C11.1, R3.1, R5.1, R19.2
/BIAS: C1.1, JP2.1, RV2.2
/ERR_LED: R1.1, SHIELD1.13
/INFO_LED: R16.2, SHIELD1.12
/SIG_ACDC: JP5.2, U1.3 (+)
/SIG_ATT: C6.1, C10.1, JP4.2, JP4.4, JP4.6, JP4.8, JP5.1
/SIG_IN: C5.1, JP4.1, P1.1 (In), R11.1, R12.1
/SIG_UC: D1.2, R9.2, SHIELD1.6, SHIELD1.AD0
/THR_IN: D2.2, R10.2, SHIELD1.7
/THR_OUT: R8.1, SHIELD1.3
/Vin: JP1.3, SHIELD1.V_IN
/x5: C5.2, C7.1, JP4.3, R12.2, R13.1
/x10: C7.2, C8.1, JP4.5, R13.2, R14.1
/x20: C8.2, C9.1, JP4.7, R14.2, R15.1
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C9.2, C11.2, D1.1, D2.1, D3.2 (K), D4.2 (K), JP2.3, P1.2 (Ext), P2.2 (PM), R7.2, R15.2, R18.2, R19.1, RV1.1, RV2.3, SHIELD1.GND1, SHIELD1.GND2, SHIELD1.GND3, SW1.1, U1.11 (V-)
unnamed: R11.2, SW1.2
unnamed: JP3.2, U1.12 (+)
unnamed: JP3.1, RV1.2
unnamed: R2.1, U1.1, U1.2 (-)
unnamed: R2.2, R4.2, U1.5 (+)
unnamed: R6.1, R7.1, U1.6 (-)
unnamed: R6.2, R9.1, U1.7
unnamed: R10.1, U1.13 (-), U1.14
unnamed: JP2.2, R4.1
unnamed: C3.1, P2.1, SHIELD1.AREF
unnamed: C10.2, JP5.3, R3.2
unnamed: R17.2, R18.1, U1.10 (+)
unnamed: D3.1 (A), R1.2
unnamed: U1.8, U1.9 (-)
unnamed: D4.1 (A), R16.1
unnamed: C2.1, JP3.3, R8.2
VCC: JP1.1, R5.2, RV1.3, RV2.1, SHIELD1.5V
VDD: C4.1, JP1.2, R17.1, U1.4 (V+)

Notes on the sheet:
ATTENUATOR
TRIGGER THRESHOLD
SIGNAL SHAPEING
UNUSED OP AMP
SHIELD
VDD SELECT
SIGNAL INPUT
LEDS
AC/DC

Board: 2 copper layers, 57.8 x 53.3 mm, 46 parts (0 on the bottom side), 33 nets.

## Commit log

2015-05-21 initial placement
2015-05-21 general PCB connections
2015-05-21 routing done
2015-07-11 added more files to ignore
2015-07-11 added AC/DC select and separate DC bias
2015-07-13 board rev1
2015-11-05 Fixed reversed power supply on OP amp
2015-11-05 added pdf schematics
2015-11-05 changed C11 footprint
